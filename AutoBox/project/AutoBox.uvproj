# Keil uVision project AutoBox.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: AutoBox +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group START
    ./: STARTUP.A51
  group USR
    ../user/: main.c timer0.c motor.c adc.c eeprom.c
